FILESEXTRAPATHS_prepend := "${THISDIR}/pytools:"

SRC_URI_append += "file://0001-obmc-pydevtools-pytools-gpioutil.patch"

