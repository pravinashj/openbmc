FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://mrw-native-olympus-xml.patch"
SRC_URI += "file://olympus.xml.patch.xml"
