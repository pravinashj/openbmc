FILESEXTRAPATHS_prepend := "${THISDIR}/linux-obmc:"
SRC_URI += "file://olympus.cfg"
SRC_URI += "file://0001-Added-KCS-interface-support.patch"
